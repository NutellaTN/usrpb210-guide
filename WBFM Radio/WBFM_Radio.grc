options:
  parameters:
    author: ASUS
    generate_options: qt_gui
    id: WBFM_Radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '1.0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: center_freq_mhz*1e6
  states: {}
- name: center_freq_mhz
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    start: '87.5'
    step: '0.1'
    stop: '108.0'
    value: '88.5'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (db)
    start: '0'
    step: '1'
    stop: '60'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '240000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Volume
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: rf_gain
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
